## drivers/seco/Kconfig
```kconfig
#
#  SECO system driver
#

menu "SECO mxc support"

config SECO_GSM_POWER_MANAGER
	tristate "SECO GSM modem power management"
endmenu
```
